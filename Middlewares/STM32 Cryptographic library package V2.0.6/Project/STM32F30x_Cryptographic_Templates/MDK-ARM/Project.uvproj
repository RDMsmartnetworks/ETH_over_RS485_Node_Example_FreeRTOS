# Keil uVision project Project.uvproj, settings and files
target STM32F30x_EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F303VC
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F30X, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_Cryptographic_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group User
    ../: main.c stm32f30x_it.c
  group STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_crc.c stm32f30x_rcc.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoFW_2_0_6.lib
