# IAR project Project.ewp, settings and files
configuration STM32L152-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_Cryptographic_Library\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L152-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152D-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD
  ILINK.IlinkOutputFile: STM32L152D-EVAL.out
  group CMSIS
    ../: system_stm32l1xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_crc.c stm32l1xx_rcc.c
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/EWARM/: M3_CryptoFW_L1xx_2_0_6.a
  group User
    ../: main.c stm32l1xx_it.c
