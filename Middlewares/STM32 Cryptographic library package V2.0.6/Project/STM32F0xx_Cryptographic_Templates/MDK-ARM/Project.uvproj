# Keil uVision project Project.uvproj, settings and files
target STM320518-EVAL (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM320518-EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX,
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_Cryptographic_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c
  group CMSIS
    ../: system_stm32f0xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group STM32_Cryptographic_Lib
    ../../../Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M0_CryptoFW_2_0_6.lib
