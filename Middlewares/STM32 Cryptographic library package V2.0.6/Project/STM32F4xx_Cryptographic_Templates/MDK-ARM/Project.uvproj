# Keil uVision project Project.uvproj, settings and files
target STM3240x_EVAL (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x7I_EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_Cryptographic_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: stm32f4xx_it.c main.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dma.c stm32f4xx_hash.c stm32f4xx_rcc.c stm32f4xx_rng.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoHW_2_0_6.lib M4_CryptoFW_RngHW_2_0_6.lib
target STM3241x_EVAL (ARM-ADS)
  device: STM32F417IG STMicroelectronics
  cpu: as above
  output: STM324xG_EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F4XX, STM32F41X, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
