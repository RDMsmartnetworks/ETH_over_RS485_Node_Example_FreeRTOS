# IAR project Project.ewp, settings and files
configuration STM3220G_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\STM32_Cryptographic_Library\inc\; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3221G_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F217IG ST STM32F217IG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; STM32F21X
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/EWARM/: M3_CryptoFW_RngHW_2_0_6.a M3_CryptoHW_2_0_6.a
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dma.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_rcc.c stm32f2xx_rng.c
  group User
    ../: main.c stm32f2xx_it.c
