# Keil uVision project Project.uvproj, settings and files
target STM3220G_EVAL (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\Libraries\STM32_Cryptographic_Library\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: stm32f2xx_it.c main.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_cryp.c stm32f2xx_dma.c stm32f2xx_hash.c stm32f2xx_rng.c stm32f2xx_rcc.c
  group CMSIS
    ../: system_stm32f2xx.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
  group STM32_Cryptographic_Lib
    ../../../Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M3_CryptoHW_2_0_6.lib M3_CryptoFW_RngHW_2_0_6.lib
target STM3221G_EVAL (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STM322xG_EVAL, STM32F2XX, STM32F21X, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
