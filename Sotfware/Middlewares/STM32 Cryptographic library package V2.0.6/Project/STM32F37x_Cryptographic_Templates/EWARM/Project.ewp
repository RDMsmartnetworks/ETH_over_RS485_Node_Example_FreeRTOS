# IAR project Project.ewp, settings and files
configuration STM32F37x_EVAL (ARM)
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F37X
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_Cryptographic_Library\inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f37x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/: system_stm32f37x.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/iar/: startup_stm32f37x.s
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/EWARM/: M4_CryptoFW_2_0_6.a
  group STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_crc.c stm32f37x_rcc.c
  group User
    ../: main.c stm32f37x_it.c
